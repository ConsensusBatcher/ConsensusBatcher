# Keil uVision project HoneyBadgerBFT-SC-M_Multi-hop.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.2
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: HoneyBadgerBFT-SC-M_Multi-hop
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\CORE;..\OBJ;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\RNG;..\HARDWARE\TIMER;..\HARDWARE\USART3;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\LORA;..\HALLIB\STM32F7xx_HAL_Driver\Inc;..\CMSIS\Include;..\CMSIS\Device\ST\STM32F7xx\Include;..\APPLICATION;..\CRYPTO;..\BN158;..\ErasureCode;..\HARDWARE\DMA;..\Threshold_Signature;..\Threshold_Enc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f7xx_hal_msp.c stm32f7xx_it.c stm32f7xx_nucleo_144.c utility.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HALLIB
    ../HALLIB/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_lptim.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c
  group CORE
    ../CORE/: cmsis_armcc.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f767xx.s
  group HARDWARE
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/RNG/: rng.c
    ../HARDWARE/TIMER/: btim.c
    ../HARDWARE/USART3/: usart3.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
  group LORA
    ../LORA/: mw1268_app.c mw1268_uart.c
  group CMSIS
    ../CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group APPLICATION
    ../APPLICATION/: tendermint2.c
  group CRYPTO
    ../CRYPTO/: sha2.c uECC.cpp uECC.h
  group Thres_Sig
    ../Threshold_Signature/: Thres_Sig.c
  group Thres_Enc
    ../Threshold_Enc/: Thres_Enc.c
  group BN158
    ../BN158/: bls_BN158.c bls_BN158.h ecdh_BN158.c ecdh_BN158.h ecp_BN158.c ecp_BN158.h ecp2_BN158.c ecp2_BN158.h eddsa_BN158.c eddsa_BN158.h fp_BN158.c fp_BN158.h fp2_BN158.c fp2_BN158.h fp4_BN158.c fp4_BN158.h fp12_BN158.c fp12_BN158.h hpke_BN158.c hpke_BN158.h mpin_BN158.c mpin_BN158.h pair_BN158.c pair_BN158.h big_160_28.c big_160_28.h config_big_160_28.h config_curve_BN158.h config_field_BN158.h arch.h aes.c hash.c hmac.c oct.c rand.c randapi.c rom_curve_BN158.c rom_field_BN158.c
software components: Security:mbed TLS 3.1.0
